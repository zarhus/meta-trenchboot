require tboot.inc

SRC_URI[sha256sum] = "5fb00e390dd5ca386fe859584e55857f43c20e5fc004c0033483a54332fe1f21"
