require tboot.inc

SRC_URI[sha256sum] = "94f91887ac2cb55817c898dea9fdf27976a12a3aa7de85b65d0e271290afc855"
