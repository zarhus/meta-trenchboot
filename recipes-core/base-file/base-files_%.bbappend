FILESEXTRAPATHS:prepend:tb-efi := "${THISDIR}/files:"

# nooelint: oelint.vars.mispell.unknown
hostname = "tb"
